Commit message: changed directory layout

File: env/walls.urdf (robot description, URDF)
Before this commit: robot colored_areas, 7 links, 6 joints
Links:
- removed link home_finish_area
- removed link home_start_area
Joints:
- removed joint home_finish_joint
- removed joint home_start_joint
